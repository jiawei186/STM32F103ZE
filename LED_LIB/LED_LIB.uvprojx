# Keil uVision project LED_LIB.uvprojx, settings and files
target LED_LIB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED_LIB +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Libraries;.\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Libraries
    ./Libraries/: startup_stm32f10x_hd.s stm32f10x.h stm32f10x_gpio.c stm32f10x_gpio.h
  group Source
    ./Source/: main.c
